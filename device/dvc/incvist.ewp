# IAR project incvist.ewp, settings and files
configuration all (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401VC ST STM32F401VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xC
  ICCARM.CCIncludePath2: templates/Inc; templates/Drivers/STM32F4xx_HAL_Driver/Inc; templates/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; templates/Drivers/CMSIS/Include; templates/Drivers/CMSIS/Device/ST/STM32F4xx/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: incvist.hex
  ILINK.IlinkOutputFile: incvist.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    templates/EWARM/: startup_stm32f401xc.s
  group Application/User
    templates/Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    templates/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_usb.c
  group Device
    ./: AboutDevice.c AboutManufacturer.c Accelerometer.c adc.c adc_pd.c adxl343.c adxl343_pd.c Archive.c ask.c AutoOff.c balloons.c calendar.c calendar_pd.c cfg.c ChipCheck.c ClearMem.c delay.c description.txt DeviceType.c factor.c Factory.c FirstProduced.c Flash.c flash_pd.c FlashDump.c fonts.c HardwareFilter.c iic.c iic_pd.c IncArchive.c IncClearMem.c IncMeasure.c IncMeasureMode.c IncMemory.c IncParams.c IncTest.c IonCalibration.c keybrd.c keybrd_pd.c KeybrdSound.c language.c lcd.c lcd_pd.c light.c light_pd.c loadcfg.c ManualOff.c ManualOff_pd.c max7400.c max7400_pd.c measure.c measure_pd.c MeasureAmplifier.c MeasureHardwareTest.c MeasuringTract.c mem.c memory.c menu.c password.c pga113.c pga113_pd.c pictures.c power.c power_pd.c sound.c sound_pd.c splash.c Status.c SupplySource.c SupplySource_pd.c system.c system_pd.c Test.c TextResources.c theme.c todo.txt usb.c usb_pd.c utils.c VistArchive.c VistCalibration.c VistClearMem.c VistMeasure.c VistMemory.c VistParams.c VistSensor.c VistTest.c VoltageDown.c xmain.c ZeroCalibration.c
